# Keil uVision project Rotation_LED.uvprojx, settings and files
target Rotation_LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Rotation_LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --no_multibyte_chars
  c include: ..\USER;..\CMSIS\CORE;..\CMSIS\STM32F10x_StdPeriph_Driver\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\APP\my_lib;..\HARDWARE\KEY;..\SYSTEM\TIMERSTAMP;..\HARDWARE\LEDARRAY;..\APP\DISPLAY;..\APP\DEBUG;..\APP\TASK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ../MAIN/: main.c
  group APP
    ../APP/my_lib/: my_lib.c
    ../APP/DISPLAY/: display.c
    ../APP/DEBUG/: debug.c
    ../APP/TASK/: task.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LEDARRAY/: ledarray.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: stm32f10x_it.c sys.c system_stm32f10x.c
    ../SYSTEM/usart/: retarget.c usart.c
    ../SYSTEM/TIMERSTAMP/: timerstamp.c
    ../CMSIS/CORE/: startup_stm32f10x_md.s
  group STM32_FWLib
    ../CMSIS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
